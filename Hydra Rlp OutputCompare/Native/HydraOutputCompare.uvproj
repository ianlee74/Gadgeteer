# Keil uVision project HydraOutputCompare.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM9RL64 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x407FFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: HydraOutputCompare
  AfterMake: fromelf --bin --output=HydraOutputCompare.bin HydraOutputCompare.axf
  c flags: Optim=1
  memory RVCT4: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x300000 size 0x10000
